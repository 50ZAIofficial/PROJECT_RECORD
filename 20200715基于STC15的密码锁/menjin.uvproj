# Keil uVision project menjin.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: menjin +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 CT107init.c main.c CT107init.h
  group APP
    ./: smg.c smg.h keyboard.c keyboard.h
  group software
    ./: password.c password.h
